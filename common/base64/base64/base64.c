/*
 * Base64 encoding/decoding (RFC1341)
 * Copyright (c) 2005-2011, Jouni Malinen <j@w1.fi>
 *
 * This software may be distributed under the terms of the BSD license.
 * See README for more details.
 */

#include "base64.h"

#include <stdlib.h>
#include <string.h>


/**
 * base64_encode - Base64 encode
 * @src: Data to be encoded
 * @dst: Destination buffer
 * @len: Length of the data to be encoded
 * @out_len: Pointer to output length variable, or %NULL if not used
 *
 * Returned buffer is nul terminated to make it easier to use as a C string.
 * The nul terminator is not included in out_len.
 */
void base64_encode(const uint8_t *src, uint8_t* dst, size_t len, size_t *out_len)
{
    const uint8_t enc_table[65] =
        "ABCDEFGHIJKLMNOPQRSTUVWXYZabcdefghijklmnopqrstuvwxyz0123456789+/";

    unsigned char *pos;
	const unsigned char *end, *in;

	end = src + len;
	in = src;
    pos = dst;

    while (end - in >= 3)
    {
        *pos++ = enc_table[in[0] >> 2];
        *pos++ = enc_table[((in[0] & 0x03) << 4) | (in[1] >> 4)];
        *pos++ = enc_table[((in[1] & 0x0f) << 2) | (in[2] >> 6)];
        *pos++ = enc_table[in[2] & 0x3f];
        in += 3;
	}

    if (end - in)
    {
        *pos++ = enc_table[in[0] >> 2];
        if (end - in == 1)
        {
            *pos++ = enc_table[(in[0] & 0x03) << 4];
            //*pos++ = '=';
        }
        else
        {
            *pos++ = enc_table[((in[0] & 0x03) << 4) |
					      (in[1] >> 4)];
            *pos++ = enc_table[(in[1] & 0x0f) << 2];
		}
        //*pos++ = '=';
    }

	*pos = '\0';
	if (out_len)
    {
        *out_len = (size_t)(pos - dst);
    }
}


/**
 * base64_decode - Base64 decode
 * @src: Data to be decoded
 * @len: Length of the data to be decoded
 * @out_len: Pointer to output length variable
 * Returns: Allocated buffer of out_len bytes of decoded data,
 * or %NULL on failure
 *
 * Caller is responsible for freeing the returned buffer.
 */
void base64_decode(const uint8_t *src, uint8_t* dst, size_t len, size_t *out_len)
{
    const uint8_t dec_table[256] = // Favoring speed over size
    {
        0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
        0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
        0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3E, 0x80, 0x80, 0x80, 0x3F,
        0x34, 0x35, 0x36, 0x37, 0x38, 0x39, 0x3A, 0x3B, 0x3C, 0x3D, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
        0x80, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0A, 0x0B, 0x0C, 0x0D, 0x0E,
        0x0F, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x80, 0x80, 0x80, 0x80, 0x80,
        0x80, 0x1A, 0x1B, 0x1C, 0x1D, 0x1E, 0x1F, 0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27, 0x28,
        0x29, 0x2A, 0x2B, 0x2C, 0x2D, 0x2E, 0x2F, 0x30, 0x31, 0x32, 0x33, 0x80, 0x80, 0x80, 0x80, 0x80,
        0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
        0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
        0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
        0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
        0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
        0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
        0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
        0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80
    };

    uint8_t *pos, block[4], tmp;
    size_t i, count;

    pos = dst;

	count = 0;
    for (i = 0; i < len; i++)
    {
        tmp = dec_table[src[i]];

        if (tmp != 0x80)
        {
            block[count] = tmp;
            count++;

            if (count == 4)
            {
                *pos++ = (uint8_t)((block[0] << 2) | (block[1] >> 4));
                *pos++ = (uint8_t)((block[1] << 4) | (block[2] >> 2));
                *pos++ = (uint8_t)((block[2] << 6) | block[3]);
                count = 0;
            }
        }
	}

    if (count == 1)
    {
        tmp = (uint8_t)(block[0] << 2);

        if (tmp != 0)
        {
            *pos++ = tmp;
        }
    }
    else if (count == 2)
    {
        *pos++ = (uint8_t)((block[0] << 2) | (block[1] >> 4));

        tmp = (uint8_t)(block[1] << 4);

        if (tmp != 0)
        {
            *pos++ = tmp;
        }
    }
    else if (count == 3)
    {
        *pos++ = (uint8_t)((block[0] << 2) | (block[1] >> 4));
        *pos++ = (uint8_t)((block[1] << 4) | (block[2] >> 2));

        tmp = (uint8_t)(block[2] << 6);

        if (tmp != 0)
        {
            *pos++ = tmp;
        }
    }

    *out_len = (size_t)(pos - dst);
}
